# Keil uVision project Touchscreen_Driver.uvproj, settings and files
target Touchscreen_Driver (6240000::V6.24::ARMCLANG)
  device: M452LD3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x11FFF) CLOCK(72000000) CPUTYPE("Cortex-M4") FPU2
  output: Touchscreen_Driver +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\M451Series\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x12000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_M451Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/M451Series/Source/: system_M451Series.c
    ../../../../Library/Device/Nuvoton/M451Series/Source/ARM/: startup_M451Series.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: retarget.c sys.c clk.c uart.c timer.c gpio.c eadc.c wdt.c fmc.c
